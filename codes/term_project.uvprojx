# Keil uVision project term_project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: term_project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.s ISR.s Freq_Detect.s Display.s DELAY100.s PortA_Init.s PortB_Init.s PortE_Init.s PortF_Init.s Timer0A.s Timer3A.s InitSysTick.s ADC0_Init.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
